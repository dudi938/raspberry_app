# Keil uVision project RobotFW_51.uvprojx, settings and files
target RobotFW_51 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: RobotFW_51
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_gpio.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_tim.c stm32f0xx_hal_flash.c stm32f0xx_hal_rtc.c stm32f0xx_hal_pwr.c
  group Application/User
    ../Src/: task_queue.c stm32f0xx_hal_msp.c stm32f0xx_it.c main.c gpio.c motor_control.c timers.c
    ../src/: debug.c uart.c pwm.c robot_main_module.c
  group Application/MDK-ARM
    ./: startup_stm32f051x8.s
    ../Src/: stm32f0xx_hal_uart.c
software components: CMSIS:CORE 4.1.0
